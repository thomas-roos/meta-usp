inherit update-rc.d
INITSCRIPT_NAME = "uspe"
INITSCRIPT_PARAMS = "start 21 2 3 4 5 . stop 97 0 1 6 ."
