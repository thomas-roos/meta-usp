CONFIG_SAH_MOD_AMXB_USP_INSTALL_DIR = "/usr/bin/mods/amxb"
